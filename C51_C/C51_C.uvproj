# Keil uVision project C51_C.uvproj, settings and files
target 8051 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: C51_C +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drivers
  group drivers
    ./drivers/: lcd.c uart.c
  group application
    ./application/: main.c Conf_tny.A51
